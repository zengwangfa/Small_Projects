# IAR project LY-STM8.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\lib\inc; ..\lib\src; ..\lib; ..\usr; ..\bsp; ..\iar
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: LY-STM8.hex
  ILINK.IlinkOutputFile: LY-STM8.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDataModel: 1
  ICCSTM8.CCDefines: NDEBUG
  group BSP
    ../BSP/: i2c.c led.c oled.c oled.h oledfont.h pcf8563.c
  group LIB
    ../LIB/src/: stm8s_clk.c stm8s_gpio.c stm8s_tim1.c stm8s_uart1.c
    ../LIB/: stm8s_conf.h
    ../LIB/inc/: stm8s_tim1.h
  group USR
    ../USR/: main.c pbdata.c pbdata.h stm8s_it.c uart.c uart.h
